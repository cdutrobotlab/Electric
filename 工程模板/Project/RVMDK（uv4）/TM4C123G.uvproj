# Keil uVision project TM4C123G.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TM4C123G
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\Libraries\driverlib;..\..\Libraries\inc;..\..\Libraries\utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../Libraries/driverlib/rvmdk/: driverlib.lib
  group User
    ../../User/: main.c startup_rvmdk.S
    ../../Libraries/utils/: uartstdio.c
